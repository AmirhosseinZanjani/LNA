** sch_path: CL_ac.sch
**.subckt CL_ac
x1 in_n1 in_p1 vdd cm outp outn 0 net2 0 0 LNA_ac
V1 vdd 0 1.8
V2 cm 0 0.9
E1 VINP1 net1 VIN1 0 0.5
E7 VINN1 net1 VIN1 0 -0.5
V4 net1 0 0.9
V7 VIN1 0 AC 1
R1 outp in_p1 225G m=1
XC1 outp in_p1 sky130_fd_pr__cap_mim_m3_2 W=5 L=5 MF=19 m=19
XC2 outn in_n1 sky130_fd_pr__cap_mim_m3_2 W=5 L=5 MF=19 m=19
R2 outn in_n1 225G m=1
XR3 VINP1 net3 0 sky130_fd_pr__res_xhigh_po_0p35 L=20 mult=1 m=1
XR4 VINN1 net4 0 sky130_fd_pr__res_xhigh_po_0p35 L=20 mult=1 m=1
x3 net5 outn outp tune[5] tune[4] tune[3] tune[2] tune[1] tune[0] o2 o1 AAFilter
X2 cm vdd 0 net2 Bias_Core
E3 CL 0 outp outn -1
V3 tune[0] 0 0
V5 tune[1] 0 0
V6 tune[2] 0 0
V8 tune[3] 0 0
V9 tune[4] 0 0
V10 tune[5] 0 1.8
x11[599] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[598] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[597] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[596] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[595] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[594] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[593] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[592] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[591] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[590] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[589] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[588] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[587] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[586] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[585] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[584] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[583] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[582] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[581] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[580] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[579] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[578] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[577] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[576] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[575] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[574] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[573] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[572] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[571] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[570] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[569] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[568] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[567] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[566] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[565] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[564] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[563] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[562] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[561] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[560] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[559] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[558] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[557] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[556] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[555] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[554] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[553] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[552] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[551] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[550] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[549] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[548] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[547] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[546] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[545] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[544] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[543] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[542] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[541] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[540] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[539] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[538] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[537] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[536] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[535] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[534] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[533] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[532] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[531] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[530] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[529] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[528] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[527] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[526] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[525] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[524] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[523] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[522] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[521] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[520] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[519] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[518] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[517] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[516] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[515] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[514] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[513] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[512] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[511] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[510] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[509] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[508] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[507] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[506] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[505] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[504] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[503] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[502] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[501] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[500] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[499] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[498] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[497] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[496] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[495] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[494] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[493] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[492] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[491] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[490] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[489] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[488] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[487] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[486] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[485] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[484] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[483] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[482] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[481] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[480] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[479] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[478] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[477] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[476] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[475] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[474] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[473] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[472] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[471] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[470] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[469] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[468] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[467] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[466] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[465] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[464] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[463] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[462] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[461] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[460] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[459] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[458] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[457] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[456] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[455] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[454] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[453] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[452] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[451] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[450] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[449] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[448] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[447] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[446] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[445] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[444] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[443] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[442] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[441] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[440] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[439] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[438] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[437] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[436] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[435] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[434] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[433] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[432] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[431] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[430] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[429] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[428] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[427] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[426] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[425] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[424] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[423] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[422] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[421] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[420] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[419] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[418] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[417] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[416] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[415] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[414] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[413] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[412] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[411] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[410] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[409] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[408] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[407] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[406] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[405] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[404] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[403] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[402] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[401] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[400] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[399] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[398] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[397] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[396] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[395] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[394] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[393] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[392] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[391] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[390] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[389] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[388] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[387] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[386] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[385] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[384] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[383] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[382] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[381] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[380] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[379] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[378] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[377] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[376] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[375] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[374] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[373] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[372] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[371] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[370] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[369] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[368] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[367] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[366] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[365] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[364] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[363] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[362] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[361] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[360] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[359] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[358] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[357] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[356] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[355] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[354] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[353] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[352] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[351] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[350] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[349] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[348] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[347] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[346] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[345] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[344] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[343] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[342] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[341] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[340] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[339] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[338] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[337] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[336] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[335] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[334] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[333] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[332] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[331] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[330] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[329] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[328] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[327] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[326] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[325] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[324] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[323] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[322] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[321] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[320] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[319] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[318] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[317] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[316] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[315] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[314] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[313] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[312] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[311] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[310] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[309] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[308] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[307] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[306] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[305] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[304] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[303] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[302] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[301] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[300] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[299] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[298] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[297] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[296] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[295] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[294] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[293] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[292] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[291] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[290] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[289] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[288] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[287] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[286] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[285] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[284] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[283] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[282] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[281] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[280] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[279] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[278] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[277] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[276] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[275] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[274] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[273] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[272] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[271] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[270] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[269] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[268] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[267] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[266] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[265] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[264] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[263] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[262] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[261] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[260] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[259] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[258] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[257] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[256] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[255] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[254] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[253] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[252] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[251] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[250] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[249] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[248] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[247] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[246] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[245] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[244] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[243] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[242] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[241] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[240] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[239] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[238] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[237] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[236] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[235] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[234] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[233] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[232] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[231] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[230] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[229] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[228] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[227] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[226] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[225] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[224] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[223] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[222] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[221] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[220] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[219] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[218] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[217] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[216] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[215] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[214] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[213] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[212] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[211] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[210] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[209] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[208] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[207] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[206] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[205] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[204] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[203] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[202] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[201] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[200] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[199] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[198] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[197] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[196] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[195] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[194] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[193] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[192] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[191] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[190] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[189] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[188] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[187] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[186] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[185] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[184] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[183] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[182] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[181] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[180] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[179] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[178] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[177] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[176] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[175] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[174] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[173] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[172] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[171] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[170] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[169] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[168] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[167] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[166] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[165] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[164] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[163] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[162] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[161] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[160] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[159] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[158] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[157] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[156] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[155] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[154] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[153] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[152] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[151] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[150] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[149] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[148] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[147] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[146] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[145] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[144] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[143] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[142] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[141] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[140] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[139] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[138] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[137] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[136] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[135] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[134] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[133] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[132] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[131] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[130] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[129] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[128] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[127] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[126] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[125] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[124] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[123] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[122] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[121] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[120] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[119] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[118] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[117] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[116] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[115] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[114] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[113] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[112] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[111] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[110] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[109] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[108] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[107] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[106] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[105] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[104] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[103] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[102] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[101] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[100] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[99] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[98] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[97] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[96] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[95] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[94] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[93] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[92] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[91] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[90] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[89] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[88] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[87] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[86] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[85] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[84] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[83] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[82] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[81] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[80] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[79] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[78] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[77] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[76] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[75] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[74] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[73] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[72] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[71] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[70] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[69] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[68] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[67] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[66] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[65] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[64] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[63] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[62] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[61] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[60] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[59] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[58] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[57] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[56] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[55] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[54] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[53] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[52] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[51] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[50] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[49] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[48] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[47] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[46] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[45] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[44] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[43] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[42] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[41] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[40] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[39] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[38] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[37] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[36] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[35] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[34] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[33] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[32] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[31] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[30] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[29] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[28] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[27] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[26] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[25] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[24] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[23] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[22] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[21] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[20] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[19] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[18] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[17] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[16] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[15] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[14] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[13] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[12] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[11] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[10] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[9] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[8] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[7] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[6] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[5] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[4] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[3] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[2] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[1] in_p1 in_p1 net3 net3 0 lna_incap_cell
x11[0] in_p1 in_p1 net3 net3 0 lna_incap_cell
x1[599] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[598] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[597] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[596] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[595] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[594] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[593] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[592] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[591] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[590] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[589] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[588] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[587] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[586] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[585] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[584] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[583] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[582] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[581] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[580] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[579] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[578] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[577] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[576] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[575] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[574] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[573] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[572] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[571] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[570] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[569] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[568] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[567] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[566] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[565] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[564] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[563] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[562] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[561] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[560] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[559] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[558] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[557] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[556] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[555] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[554] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[553] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[552] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[551] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[550] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[549] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[548] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[547] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[546] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[545] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[544] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[543] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[542] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[541] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[540] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[539] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[538] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[537] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[536] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[535] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[534] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[533] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[532] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[531] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[530] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[529] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[528] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[527] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[526] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[525] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[524] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[523] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[522] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[521] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[520] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[519] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[518] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[517] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[516] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[515] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[514] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[513] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[512] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[511] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[510] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[509] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[508] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[507] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[506] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[505] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[504] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[503] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[502] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[501] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[500] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[499] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[498] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[497] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[496] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[495] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[494] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[493] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[492] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[491] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[490] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[489] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[488] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[487] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[486] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[485] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[484] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[483] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[482] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[481] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[480] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[479] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[478] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[477] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[476] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[475] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[474] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[473] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[472] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[471] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[470] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[469] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[468] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[467] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[466] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[465] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[464] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[463] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[462] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[461] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[460] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[459] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[458] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[457] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[456] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[455] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[454] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[453] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[452] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[451] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[450] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[449] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[448] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[447] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[446] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[445] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[444] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[443] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[442] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[441] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[440] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[439] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[438] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[437] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[436] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[435] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[434] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[433] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[432] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[431] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[430] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[429] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[428] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[427] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[426] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[425] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[424] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[423] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[422] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[421] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[420] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[419] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[418] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[417] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[416] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[415] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[414] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[413] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[412] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[411] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[410] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[409] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[408] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[407] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[406] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[405] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[404] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[403] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[402] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[401] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[400] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[399] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[398] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[397] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[396] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[395] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[394] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[393] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[392] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[391] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[390] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[389] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[388] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[387] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[386] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[385] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[384] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[383] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[382] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[381] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[380] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[379] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[378] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[377] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[376] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[375] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[374] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[373] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[372] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[371] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[370] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[369] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[368] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[367] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[366] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[365] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[364] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[363] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[362] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[361] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[360] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[359] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[358] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[357] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[356] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[355] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[354] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[353] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[352] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[351] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[350] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[349] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[348] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[347] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[346] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[345] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[344] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[343] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[342] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[341] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[340] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[339] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[338] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[337] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[336] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[335] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[334] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[333] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[332] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[331] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[330] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[329] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[328] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[327] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[326] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[325] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[324] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[323] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[322] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[321] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[320] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[319] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[318] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[317] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[316] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[315] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[314] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[313] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[312] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[311] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[310] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[309] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[308] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[307] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[306] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[305] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[304] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[303] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[302] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[301] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[300] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[299] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[298] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[297] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[296] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[295] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[294] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[293] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[292] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[291] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[290] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[289] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[288] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[287] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[286] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[285] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[284] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[283] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[282] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[281] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[280] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[279] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[278] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[277] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[276] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[275] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[274] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[273] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[272] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[271] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[270] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[269] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[268] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[267] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[266] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[265] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[264] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[263] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[262] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[261] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[260] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[259] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[258] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[257] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[256] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[255] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[254] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[253] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[252] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[251] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[250] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[249] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[248] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[247] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[246] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[245] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[244] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[243] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[242] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[241] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[240] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[239] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[238] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[237] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[236] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[235] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[234] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[233] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[232] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[231] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[230] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[229] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[228] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[227] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[226] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[225] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[224] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[223] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[222] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[221] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[220] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[219] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[218] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[217] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[216] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[215] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[214] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[213] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[212] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[211] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[210] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[209] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[208] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[207] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[206] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[205] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[204] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[203] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[202] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[201] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[200] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[199] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[198] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[197] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[196] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[195] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[194] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[193] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[192] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[191] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[190] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[189] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[188] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[187] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[186] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[185] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[184] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[183] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[182] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[181] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[180] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[179] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[178] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[177] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[176] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[175] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[174] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[173] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[172] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[171] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[170] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[169] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[168] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[167] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[166] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[165] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[164] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[163] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[162] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[161] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[160] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[159] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[158] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[157] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[156] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[155] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[154] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[153] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[152] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[151] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[150] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[149] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[148] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[147] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[146] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[145] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[144] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[143] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[142] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[141] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[140] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[139] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[138] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[137] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[136] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[135] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[134] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[133] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[132] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[131] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[130] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[129] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[128] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[127] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[126] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[125] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[124] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[123] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[122] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[121] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[120] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[119] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[118] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[117] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[116] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[115] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[114] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[113] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[112] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[111] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[110] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[109] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[108] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[107] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[106] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[105] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[104] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[103] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[102] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[101] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[100] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[99] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[98] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[97] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[96] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[95] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[94] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[93] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[92] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[91] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[90] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[89] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[88] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[87] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[86] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[85] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[84] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[83] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[82] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[81] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[80] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[79] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[78] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[77] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[76] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[75] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[74] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[73] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[72] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[71] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[70] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[69] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[68] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[67] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[66] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[65] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[64] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[63] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[62] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[61] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[60] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[59] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[58] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[57] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[56] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[55] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[54] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[53] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[52] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[51] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[50] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[49] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[48] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[47] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[46] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[45] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[44] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[43] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[42] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[41] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[40] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[39] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[38] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[37] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[36] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[35] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[34] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[33] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[32] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[31] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[30] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[29] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[28] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[27] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[26] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[25] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[24] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[23] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[22] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[21] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[20] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[19] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[18] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[17] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[16] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[15] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[14] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[13] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[12] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[11] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[10] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[9] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[8] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[7] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[6] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[5] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[4] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[3] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[2] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[1] in_n1 in_n1 net4 net4 0 lna_incap_cell
x1[0] in_n1 in_n1 net4 net4 0 lna_incap_cell
**** begin user architecture code
.lib $::SKYWATER_MODELS/sky130.lib.spice tt


.options savecurrents gmin=1e-13
*ic v(VM5)=0.9 v(VM6)=0.9
.control


save all

save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[id]
save @m.xm11.msky130_fd_pr__pfet_01v8_lvt[vgs]


*nmos
save @m.xm3.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm3.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm3.msky130_fd_pr__nfet_01v8_lvt[vds]

save @m.xm6.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm6.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm6.msky130_fd_pr__nfet_01v8_lvt[vds]

save @m.xm8.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm8.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm8.msky130_fd_pr__nfet_01v8_lvt[vds]

save @m.xm9.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm9.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm9.msky130_fd_pr__nfet_01v8_lvt[vds]

save @m.xm18.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm18.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm18.msky130_fd_pr__nfet_01v8_lvt[vds]

save @m.xm19.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm19.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm19.msky130_fd_pr__nfet_01v8_lvt[vds]

save @m.xm25.msky130_fd_pr__nfet_01v8_lvt[vgs]
save @m.xm25.msky130_fd_pr__nfet_01v8_lvt[vth]
save @m.xm25.msky130_fd_pr__nfet_01v8_lvt[vds]

*pmos

save @m.xm1.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm1.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm1.msky130_fd_pr__pfet_01v8_lvt[vds]


save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vds]


save @m.xm10.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm10.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm10.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm13.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm13.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm13.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm4.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm5.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm16.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm16.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm16.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm17.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm17.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm3.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm20.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm20.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm20.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm21.msky130_fd_pr__pfet_01v8_lvt[vgs]
save @m.xm21.msky130_fd_pr__pfet_01v8_lvt[vth]
save @m.xm21.msky130_fd_pr__pfet_01v8_lvt[vds]

save @m.xm7.msky130_fd_pr__nfet_01v8_lvt[vth]

save @m.xm1.msky130_fd_pr__pfet_01v8[vgs]

save @m.xm1.msky130_fd_pr__nfet_01v8_lvt[gm]


save @m.xm1.msky130_fd_pr__nfet_01v8_lvt[gds]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gm]

save @m.xm23.msky130_fd_pr__nfet_01v8[cgs]
save @m.xm4.msky130_fd_pr__pfet_01v8[cgs]
save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[cgs]



save @m.xm2.msky130_fd_pr__pfet_01v8_lvt[gds]


op
write CL_ac.raw
*set appendwrite


.endc
.control



*tran 50u 1500m
*save all
*plot v(Outp)-v(outn)


noise V(Outp,Outn) V7 dec 100 0.1 128
print inoise_total onoise_total
setplot noise1
plot inoise_spectrum

ac dec 10 0.1 10k
let gaind=(v(outp)-v(outn))/(v(VINP1)-v(VINN1))
let lg=vr/VIN1
let BG=(OL/CL)-1
let phase=180*cph(BG)/pi
plot db(gaind)
plot db(BG) phase


.endc






.include $::SKYWATER_STDCELLS/sky130_fd_sc_hd.spice


.include /foss/designs/LNA/lna_incap_cell.spice

**** end user architecture code
**.ends
.end
