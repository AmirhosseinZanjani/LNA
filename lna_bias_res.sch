v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -290 -300 -290 -120 {
lab=VSS_RES}
N 30 -300 30 -120 {
lab=VSS_RES}
N 380 -300 380 -120 {
lab=VSS_RES}
N 710 -300 710 -120 {
lab=VSS_RES}
N 1050 -300 1050 -120 {
lab=VSS_RES}
N 1370 -300 1370 -120 {
lab=VSS_RES}
N 1720 -300 1720 -120 {
lab=VSS_RES}
N 2050 -300 2050 -120 {
lab=VSS_RES}
N -310 -330 10 -330 {
lab=#net1}
N 10 -90 360 -90 {
lab=#net2}
N 360 -330 690 -330 {
lab=#net3}
N 690 -90 1030 -90 {
lab=#net4}
N 1030 -330 1350 -330 {
lab=#net5}
N 1350 -90 1700 -90 {
lab=#net6}
N 1700 -330 2030 -330 {
lab=#net7}
N -290 -300 30 -300 {
lab=VSS_RES}
N 30 -120 380 -120 {
lab=VSS_RES}
N 380 -300 710 -300 {
lab=VSS_RES}
N 710 -120 1050 -120 {
lab=VSS_RES}
N 1050 -300 1370 -300 {
lab=VSS_RES}
N 1370 -120 1720 -120 {
lab=VSS_RES}
N 1720 -300 2050 -300 {
lab=VSS_RES}
N 2030 -80 2260 -80 {
lab=#net8}
N 2030 -90 2030 -80 {
lab=#net8}
N 2280 -300 2280 -120 {
lab=VSS_RES}
N 2600 -300 2600 -120 {
lab=VSS_RES}
N 2950 -300 2950 -120 {
lab=VSS_RES}
N 3280 -300 3280 -120 {
lab=VSS_RES}
N 3620 -300 3620 -120 {
lab=VSS_RES}
N 3940 -300 3940 -120 {
lab=VSS_RES}
N 4290 -300 4290 -120 {
lab=VSS_RES}
N 4620 -300 4620 -120 {
lab=VSS_RES}
N 2260 -330 2580 -330 {
lab=#net9}
N 2580 -90 2930 -90 {
lab=#net10}
N 2930 -330 3260 -330 {
lab=#net11}
N 3260 -90 3600 -90 {
lab=#net12}
N 3600 -330 3920 -330 {
lab=#net13}
N 3920 -90 4270 -90 {
lab=#net14}
N 4270 -330 4600 -330 {
lab=#net15}
N 2280 -300 2600 -300 {
lab=VSS_RES}
N 2600 -120 2950 -120 {
lab=VSS_RES}
N 2950 -300 3280 -300 {
lab=VSS_RES}
N 3280 -120 3620 -120 {
lab=VSS_RES}
N 3620 -300 3940 -300 {
lab=VSS_RES}
N 3940 -120 4290 -120 {
lab=VSS_RES}
N 4290 -300 4620 -300 {
lab=VSS_RES}
N 4600 -80 4830 -80 {
lab=#net16}
N 4600 -90 4600 -80 {
lab=#net16}
N 2260 -90 2260 -80 {
lab=#net8}
N 2050 -120 2280 -120 {
lab=VSS_RES}
N -290 180 -290 360 {
lab=VSS_RES}
N 30 180 30 360 {
lab=VSS_RES}
N 380 180 380 360 {
lab=VSS_RES}
N 710 180 710 360 {
lab=VSS_RES}
N 1050 180 1050 360 {
lab=VSS_RES}
N 1370 180 1370 360 {
lab=VSS_RES}
N 1720 180 1720 360 {
lab=VSS_RES}
N 2050 180 2050 360 {
lab=VSS_RES}
N -310 150 10 150 {
lab=#net17}
N 10 390 360 390 {
lab=#net18}
N 360 150 690 150 {
lab=#net19}
N 690 390 1030 390 {
lab=#net20}
N 1030 150 1350 150 {
lab=#net21}
N 1350 390 1700 390 {
lab=#net22}
N 1700 150 2030 150 {
lab=#net23}
N -290 180 30 180 {
lab=VSS_RES}
N 30 360 380 360 {
lab=VSS_RES}
N 380 180 710 180 {
lab=VSS_RES}
N 710 360 1050 360 {
lab=VSS_RES}
N 1050 180 1370 180 {
lab=VSS_RES}
N 1370 360 1720 360 {
lab=VSS_RES}
N 1720 180 2050 180 {
lab=VSS_RES}
N 2030 400 2260 400 {
lab=#net24}
N 2030 390 2030 400 {
lab=#net24}
N 2280 180 2280 360 {
lab=VSS_RES}
N 2600 180 2600 360 {
lab=VSS_RES}
N 2950 180 2950 360 {
lab=VSS_RES}
N 3280 180 3280 360 {
lab=VSS_RES}
N 3620 180 3620 360 {
lab=VSS_RES}
N 3940 180 3940 360 {
lab=VSS_RES}
N 4290 180 4290 360 {
lab=VSS_RES}
N 4620 180 4620 360 {
lab=VSS_RES}
N 2260 150 2580 150 {
lab=#net25}
N 2580 390 2930 390 {
lab=#net26}
N 2930 150 3260 150 {
lab=#net27}
N 3260 390 3600 390 {
lab=#net28}
N 3600 150 3920 150 {
lab=#net29}
N 3920 390 4270 390 {
lab=#net30}
N 4270 150 4600 150 {
lab=#net31}
N 2280 180 2600 180 {
lab=VSS_RES}
N 2600 360 2950 360 {
lab=VSS_RES}
N 2950 180 3280 180 {
lab=VSS_RES}
N 3280 360 3620 360 {
lab=VSS_RES}
N 3620 180 3940 180 {
lab=VSS_RES}
N 3940 360 4290 360 {
lab=VSS_RES}
N 4290 180 4620 180 {
lab=VSS_RES}
N 4600 400 4830 400 {
lab=#net16}
N 4600 390 4600 400 {
lab=#net16}
N 2260 390 2260 400 {
lab=#net24}
N 2050 360 2280 360 {
lab=VSS_RES}
N 4830 -80 4830 400 {
lab=#net16}
N 4620 -120 4620 180 {
lab=VSS_RES}
N -290 740 -290 920 {
lab=VSS_RES}
N 30 740 30 920 {
lab=VSS_RES}
N 380 740 380 920 {
lab=VSS_RES}
N 710 740 710 920 {
lab=VSS_RES}
N 1050 740 1050 920 {
lab=VSS_RES}
N 1370 740 1370 920 {
lab=VSS_RES}
N 1720 740 1720 920 {
lab=VSS_RES}
N 2050 740 2050 920 {
lab=VSS_RES}
N -310 710 10 710 {
lab=#net32}
N 10 950 360 950 {
lab=#net33}
N 360 710 690 710 {
lab=#net34}
N 690 950 1030 950 {
lab=#net35}
N 1030 710 1350 710 {
lab=#net36}
N 1350 950 1700 950 {
lab=#net37}
N 1700 710 2030 710 {
lab=#net38}
N -290 740 30 740 {
lab=VSS_RES}
N 30 920 380 920 {
lab=VSS_RES}
N 380 740 710 740 {
lab=VSS_RES}
N 710 920 1050 920 {
lab=VSS_RES}
N 1050 740 1370 740 {
lab=VSS_RES}
N 1370 920 1720 920 {
lab=VSS_RES}
N 1720 740 2050 740 {
lab=VSS_RES}
N 2030 960 2260 960 {
lab=#net39}
N 2030 950 2030 960 {
lab=#net39}
N 2280 740 2280 920 {
lab=VSS_RES}
N 2600 740 2600 920 {
lab=VSS_RES}
N 2950 740 2950 920 {
lab=VSS_RES}
N 3280 740 3280 920 {
lab=VSS_RES}
N 3620 740 3620 920 {
lab=VSS_RES}
N 3940 740 3940 920 {
lab=VSS_RES}
N 4290 740 4290 920 {
lab=VSS_RES}
N 4620 740 4620 920 {
lab=VSS_RES}
N 2260 710 2580 710 {
lab=#net40}
N 2580 950 2930 950 {
lab=#net41}
N 2930 710 3260 710 {
lab=#net42}
N 3260 950 3600 950 {
lab=#net43}
N 3600 710 3920 710 {
lab=#net44}
N 3920 950 4270 950 {
lab=#net45}
N 4270 710 4600 710 {
lab=#net46}
N 2280 740 2600 740 {
lab=VSS_RES}
N 2600 920 2950 920 {
lab=VSS_RES}
N 2950 740 3280 740 {
lab=VSS_RES}
N 3280 920 3620 920 {
lab=VSS_RES}
N 3620 740 3940 740 {
lab=VSS_RES}
N 3940 920 4290 920 {
lab=VSS_RES}
N 4290 740 4620 740 {
lab=VSS_RES}
N 4600 960 4830 960 {
lab=#net47}
N 4600 950 4600 960 {
lab=#net47}
N 2260 950 2260 960 {
lab=#net39}
N 2050 920 2280 920 {
lab=VSS_RES}
N -520 390 -310 390 {
lab=#net48}
N -520 390 -520 940 {
lab=#net48}
N -520 940 -520 950 {
lab=#net48}
N -520 950 -310 950 {
lab=#net48}
N -290 360 -290 740 {
lab=VSS_RES}
N 4700 -690 4700 -80 {
lab=#net16}
N 4830 960 5090 960 {
lab=#net47}
N 5670 -980 5670 -690 {
lab=#net49}
N 2160 -1160 2160 400 {
lab=#net24}
N 2420 -1160 5090 -1160 {
lab=#net49}
N 5670 -1160 5670 -980 {
lab=#net49}
N 3440 -920 3440 390 {
lab=#net28}
N 5670 -1400 5670 -1160 {
lab=#net49}
N 970 -1400 970 380 {
lab=#net20}
N 970 380 970 390 {
lab=#net20}
N 1230 -1400 3060 -1400 {
lab=#net49}
N 3060 -1400 5090 -1400 {
lab=#net49}
N 1230 -1630 3060 -1630 {
lab=#net49}
N 3060 -1630 5090 -1630 {
lab=#net49}
N 0 -1630 1230 -1630 {
lab=#net49}
N -520 -1630 -260 -1630 {
lab=#net48}
N -520 -1630 -520 390 {
lab=#net48}
N 910 960 910 1810 {
lab=#net35}
N 910 950 910 960 {
lab=#net35}
N 2180 960 2180 1430 {
lab=#net39}
N 3450 950 3450 1170 {
lab=#net43}
N -260 -1630 -160 -1630 {
lab=#net48}
N 970 -1400 1070 -1400 {
lab=#net20}
N 2160 -1160 2260 -1160 {
lab=#net24}
N 3440 -920 3540 -920 {
lab=#net28}
N 3700 -920 5090 -920 {
lab=#net49}
N 4700 -690 4800 -690 {
lab=#net16}
N 910 1810 1010 1810 {
lab=#net35}
N 2180 1430 2280 1430 {
lab=#net39}
N 3450 1170 3550 1170 {
lab=#net43}
N -290 3070 -290 3250 {
lab=VSS_RES}
N 30 3070 30 3250 {
lab=VSS_RES}
N 380 3070 380 3250 {
lab=VSS_RES}
N 710 3070 710 3250 {
lab=VSS_RES}
N 1050 3070 1050 3250 {
lab=VSS_RES}
N 1370 3070 1370 3250 {
lab=VSS_RES}
N 1720 3070 1720 3250 {
lab=VSS_RES}
N 2050 3070 2050 3250 {
lab=VSS_RES}
N -310 3040 10 3040 {
lab=#net50}
N 10 3280 360 3280 {
lab=#net51}
N 360 3040 690 3040 {
lab=#net52}
N 690 3280 1030 3280 {
lab=#net53}
N 1030 3040 1350 3040 {
lab=#net54}
N 1350 3280 1700 3280 {
lab=#net55}
N 1700 3040 2030 3040 {
lab=#net56}
N -290 3070 30 3070 {
lab=VSS_RES}
N 30 3250 380 3250 {
lab=VSS_RES}
N 380 3070 710 3070 {
lab=VSS_RES}
N 710 3250 1050 3250 {
lab=VSS_RES}
N 1050 3070 1370 3070 {
lab=VSS_RES}
N 1370 3250 1720 3250 {
lab=VSS_RES}
N 1720 3070 2050 3070 {
lab=VSS_RES}
N 2030 3290 2260 3290 {
lab=#net57}
N 2030 3280 2030 3290 {
lab=#net57}
N 2280 3070 2280 3250 {
lab=VSS_RES}
N 2600 3070 2600 3250 {
lab=VSS_RES}
N 2950 3070 2950 3250 {
lab=VSS_RES}
N 3280 3070 3280 3250 {
lab=VSS_RES}
N 3620 3070 3620 3250 {
lab=VSS_RES}
N 3940 3070 3940 3250 {
lab=VSS_RES}
N 4290 3070 4290 3250 {
lab=VSS_RES}
N 4620 3070 4620 3250 {
lab=VSS_RES}
N 2260 3040 2580 3040 {
lab=#net58}
N 2580 3280 2930 3280 {
lab=#net59}
N 2930 3040 3260 3040 {
lab=#net60}
N 3260 3280 3600 3280 {
lab=#net61}
N 3600 3040 3920 3040 {
lab=#net62}
N 3920 3280 4270 3280 {
lab=#net63}
N 4270 3040 4600 3040 {
lab=#net64}
N 2280 3070 2600 3070 {
lab=VSS_RES}
N 2600 3250 2950 3250 {
lab=VSS_RES}
N 2950 3070 3280 3070 {
lab=VSS_RES}
N 3280 3250 3620 3250 {
lab=VSS_RES}
N 3620 3070 3940 3070 {
lab=VSS_RES}
N 3940 3250 4290 3250 {
lab=VSS_RES}
N 4290 3070 4620 3070 {
lab=VSS_RES}
N 4600 3290 4830 3290 {
lab=#net47}
N 4600 3280 4600 3290 {
lab=#net47}
N 2260 3280 2260 3290 {
lab=#net57}
N 2050 3250 2280 3250 {
lab=VSS_RES}
N -520 3280 -310 3280 {
lab=v_res_top}
N 4830 3290 5090 3290 {
lab=#net47}
N 5090 960 5090 2270 {
lab=#net47}
N 5090 1170 5230 1170 {
lab=#net47}
N 5230 1170 5330 1170 {
lab=#net47}
N 3500 2750 3600 2750 {
lab=#net61}
N 2190 2570 2290 2570 {
lab=#net57}
N 3500 2750 3500 3280 {
lab=#net61}
N 790 2380 890 2380 {
lab=#net53}
N 2190 2570 2190 2720 {
lab=#net57}
N 2190 2720 2190 3290 {
lab=#net57}
N 790 2580 790 3280 {
lab=#net53}
N 790 2380 790 2580 {
lab=#net53}
N 5080 -690 5670 -690 {
lab=#net49}
N 4960 -690 5080 -690 {
lab=#net49}
N 5090 -920 5670 -920 {
lab=#net49}
N 5090 -1160 5670 -1160 {
lab=#net49}
N 5090 -1400 5670 -1400 {
lab=#net49}
N 5090 -1630 5670 -1630 {
lab=#net49}
N 5670 -1630 5670 -1400 {
lab=#net49}
N 5680 -700 5680 1150 {
lab=v_res_top}
N 5680 1150 5680 1160 {
lab=v_res_top}
N 5680 1160 5680 1170 {
lab=v_res_top}
N 5490 1170 5680 1170 {
lab=v_res_top}
N 1220 1810 5670 1810 {
lab=v_res_top}
N 5680 1170 5680 1810 {
lab=v_res_top}
N 5670 1810 5680 1810 {
lab=v_res_top}
N 2440 1430 2440 1810 {
lab=v_res_top}
N 3710 1170 3710 1810 {
lab=v_res_top}
N 1050 2380 2640 2380 {
lab=v_res_top}
N 2450 2380 2450 2570 {
lab=v_res_top}
N 3760 2520 3760 2750 {
lab=v_res_top}
N 2630 2380 3790 2380 {
lab=v_res_top}
N 3760 2380 3760 2520 {
lab=v_res_top}
N 3780 2380 5610 2380 {
lab=v_res_top}
N 5680 1810 5680 2380 {
lab=v_res_top}
N 5600 2380 5680 2380 {
lab=v_res_top}
N 5090 2260 5090 3290 {
lab=#net47}
N -290 920 -290 3070 {
lab=VSS_RES}
N 5680 2370 5680 3720 {
lab=v_res_top}
N -460 3720 5680 3720 {
lab=v_res_top}
N -460 3280 -460 3720 {
lab=v_res_top}
N 1170 1810 1220 1810 {
lab=v_res_top}
C {devices/iopin.sym} -770 -175 0 0 {name=p2 lab=v_res_bottom}
C {devices/iopin.sym} -760 -115 0 0 {name=p1 lab=v_res_top}
C {devices/iopin.sym} -760 -45 0 0 {name=p3 lab=VSS_RES}
C {devices/lab_pin.sym} -290 -120 2 0 {name=p11 sig_type=std_logic lab=VSS_RES}
C {devices/lab_pin.sym} -310 -90 3 0 {name=p12 sig_type=std_logic lab=v_res_bottom}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 -300 2 0 {name=R29
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 -240 2 0 {name=R1
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 -180 2 0 {name=R2
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 -120 2 0 {name=R3
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 -300 2 0 {name=R4
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 -240 2 0 {name=R5
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 -180 2 0 {name=R6
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 -120 2 0 {name=R7
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 -300 2 0 {name=R8
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 -240 2 0 {name=R9
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 -180 2 0 {name=R10
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 -120 2 0 {name=R11
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 -300 2 0 {name=R12
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 -240 2 0 {name=R13
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 -180 2 0 {name=R14
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 -120 2 0 {name=R15
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 -300 2 0 {name=R16
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 -240 2 0 {name=R17
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 -180 2 0 {name=R18
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 -120 2 0 {name=R19
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 -300 2 0 {name=R20
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 -240 2 0 {name=R21
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 -180 2 0 {name=R22
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 -120 2 0 {name=R23
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 -300 2 0 {name=R24
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 -240 2 0 {name=R25
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 -180 2 0 {name=R26
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 -120 2 0 {name=R27
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 -300 2 0 {name=R28
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 -240 2 0 {name=R30
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 -180 2 0 {name=R31
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 -120 2 0 {name=R32
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/iopin.sym} -760 5 0 0 {name=p4 lab=VDD_RES}
C {devices/iopin.sym} -760 -245 0 0 {name=p10 lab=res_tune_decoder_out[11:0]}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 -300 2 0 {name=R33
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 -240 2 0 {name=R34
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 -180 2 0 {name=R35
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 -120 2 0 {name=R36
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 -300 2 0 {name=R37
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 -240 2 0 {name=R38
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 -180 2 0 {name=R39
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 -120 2 0 {name=R40
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 -300 2 0 {name=R41
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 -240 2 0 {name=R42
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 -180 2 0 {name=R43
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 -120 2 0 {name=R44
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 -300 2 0 {name=R45
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 -240 2 0 {name=R46
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 -180 2 0 {name=R47
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 -120 2 0 {name=R48
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 -300 2 0 {name=R49
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 -240 2 0 {name=R50
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 -180 2 0 {name=R51
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 -120 2 0 {name=R52
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 -300 2 0 {name=R53
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 -240 2 0 {name=R54
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 -180 2 0 {name=R55
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 -120 2 0 {name=R56
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 -300 2 0 {name=R57
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 -240 2 0 {name=R58
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 -180 2 0 {name=R59
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 -120 2 0 {name=R60
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 -300 2 0 {name=R61
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 -240 2 0 {name=R62
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 -180 2 0 {name=R63
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 -120 2 0 {name=R64
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 180 2 0 {name=R65
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 240 2 0 {name=R66
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 300 2 0 {name=R67
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 360 2 0 {name=R68
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 180 2 0 {name=R69
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 240 2 0 {name=R70
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 300 2 0 {name=R71
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 360 2 0 {name=R72
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 180 2 0 {name=R73
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 240 2 0 {name=R74
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 300 2 0 {name=R75
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 360 2 0 {name=R76
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 180 2 0 {name=R77
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 240 2 0 {name=R78
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 300 2 0 {name=R79
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 360 2 0 {name=R80
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 180 2 0 {name=R81
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 240 2 0 {name=R82
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 300 2 0 {name=R83
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 360 2 0 {name=R84
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 180 2 0 {name=R85
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 240 2 0 {name=R86
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 300 2 0 {name=R87
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 360 2 0 {name=R88
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 180 2 0 {name=R89
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 240 2 0 {name=R90
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 300 2 0 {name=R91
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 360 2 0 {name=R92
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 180 2 0 {name=R93
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 240 2 0 {name=R94
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 300 2 0 {name=R95
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 360 2 0 {name=R96
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 180 2 0 {name=R97
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 240 2 0 {name=R98
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 300 2 0 {name=R99
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 360 2 0 {name=R100
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 180 2 0 {name=R101
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 240 2 0 {name=R102
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 300 2 0 {name=R103
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 360 2 0 {name=R104
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 180 2 0 {name=R105
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 240 2 0 {name=R106
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 300 2 0 {name=R107
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 360 2 0 {name=R108
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 180 2 0 {name=R109
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 240 2 0 {name=R110
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 300 2 0 {name=R111
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 360 2 0 {name=R112
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 180 2 0 {name=R113
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 240 2 0 {name=R114
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 300 2 0 {name=R115
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 360 2 0 {name=R116
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 180 2 0 {name=R117
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 240 2 0 {name=R118
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 300 2 0 {name=R119
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 360 2 0 {name=R120
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 180 2 0 {name=R121
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 240 2 0 {name=R122
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 300 2 0 {name=R123
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 360 2 0 {name=R124
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 180 2 0 {name=R125
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 240 2 0 {name=R126
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 300 2 0 {name=R127
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 360 2 0 {name=R128
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 740 2 0 {name=R129
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 800 2 0 {name=R130
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 860 2 0 {name=R131
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 920 2 0 {name=R132
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 740 2 0 {name=R133
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 800 2 0 {name=R134
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 860 2 0 {name=R135
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 920 2 0 {name=R136
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 740 2 0 {name=R137
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 800 2 0 {name=R138
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 860 2 0 {name=R139
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 920 2 0 {name=R140
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 740 2 0 {name=R141
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 800 2 0 {name=R142
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 860 2 0 {name=R143
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 920 2 0 {name=R144
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 740 2 0 {name=R145
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 800 2 0 {name=R146
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 860 2 0 {name=R147
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 920 2 0 {name=R148
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 740 2 0 {name=R149
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 800 2 0 {name=R150
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 860 2 0 {name=R151
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 920 2 0 {name=R152
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 740 2 0 {name=R153
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 800 2 0 {name=R154
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 860 2 0 {name=R155
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 920 2 0 {name=R156
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 740 2 0 {name=R157
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 800 2 0 {name=R158
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 860 2 0 {name=R159
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 920 2 0 {name=R160
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 740 2 0 {name=R161
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 800 2 0 {name=R162
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 860 2 0 {name=R163
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 920 2 0 {name=R164
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 740 2 0 {name=R165
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 800 2 0 {name=R166
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 860 2 0 {name=R167
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 920 2 0 {name=R168
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 740 2 0 {name=R169
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 800 2 0 {name=R170
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 860 2 0 {name=R171
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 920 2 0 {name=R172
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 740 2 0 {name=R173
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 800 2 0 {name=R174
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 860 2 0 {name=R175
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 920 2 0 {name=R176
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 740 2 0 {name=R177
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 800 2 0 {name=R178
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 860 2 0 {name=R179
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 920 2 0 {name=R180
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 740 2 0 {name=R181
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 800 2 0 {name=R182
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 860 2 0 {name=R183
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 920 2 0 {name=R184
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 740 2 0 {name=R185
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 800 2 0 {name=R186
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 860 2 0 {name=R187
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 920 2 0 {name=R188
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 740 2 0 {name=R189
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 800 2 0 {name=R190
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 860 2 0 {name=R191
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 920 2 0 {name=R192
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {LNA/lna_tg.sym} -140 -1640 0 0 {name=x1}
C {devices/lab_pin.sym} -60 -1660 1 0 {name=p13 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} -100 -1660 1 0 {name=p17 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 1090 -1410 0 0 {name=x2}
C {devices/lab_pin.sym} 1170 -1430 1 0 {name=p9 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 1130 -1430 1 0 {name=p19 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 2280 -1170 0 0 {name=x3}
C {devices/lab_pin.sym} 2360 -1190 1 0 {name=p14 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 2320 -1190 1 0 {name=p21 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 3560 -930 0 0 {name=x4}
C {devices/lab_pin.sym} 3640 -950 1 0 {name=p15 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 3600 -950 1 0 {name=p23 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 4820 -700 0 0 {name=x5}
C {devices/lab_pin.sym} 4900 -720 1 0 {name=p16 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 4860 -720 1 0 {name=p25 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 1030 1800 0 0 {name=x6}
C {devices/lab_pin.sym} 1110 1780 1 0 {name=p8 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 1070 1780 1 0 {name=p27 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 2300 1420 0 0 {name=x7}
C {devices/lab_pin.sym} 2380 1400 1 0 {name=p6 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 2340 1400 1 0 {name=p29 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 3570 1160 0 0 {name=x8}
C {devices/lab_pin.sym} 3650 1140 1 0 {name=p7 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 3610 1140 1 0 {name=p31 sig_type=std_logic lab=VSS_RES}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 3070 2 0 {name=R193
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 3130 2 0 {name=R194
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 3190 2 0 {name=R195
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} -310 3250 2 0 {name=R196
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 3070 2 0 {name=R197
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 3130 2 0 {name=R198
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 3190 2 0 {name=R199
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 10 3250 2 0 {name=R200
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 3070 2 0 {name=R201
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 3130 2 0 {name=R202
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 3190 2 0 {name=R203
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 360 3250 2 0 {name=R204
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 3070 2 0 {name=R205
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 3130 2 0 {name=R206
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 3190 2 0 {name=R207
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 690 3250 2 0 {name=R208
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 3070 2 0 {name=R209
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 3130 2 0 {name=R210
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 3190 2 0 {name=R211
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1030 3250 2 0 {name=R212
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 3070 2 0 {name=R213
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 3130 2 0 {name=R214
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 3190 2 0 {name=R215
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1350 3250 2 0 {name=R216
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 3070 2 0 {name=R217
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 3130 2 0 {name=R218
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 3190 2 0 {name=R219
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 1700 3250 2 0 {name=R220
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 3070 2 0 {name=R221
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 3130 2 0 {name=R222
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 3190 2 0 {name=R223
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2030 3250 2 0 {name=R224
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 3070 2 0 {name=R225
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 3130 2 0 {name=R226
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 3190 2 0 {name=R227
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2260 3250 2 0 {name=R228
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 3070 2 0 {name=R229
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 3130 2 0 {name=R230
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 3190 2 0 {name=R231
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2580 3250 2 0 {name=R232
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 3070 2 0 {name=R233
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 3130 2 0 {name=R234
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 3190 2 0 {name=R235
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 2930 3250 2 0 {name=R236
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 3070 2 0 {name=R237
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 3130 2 0 {name=R238
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 3190 2 0 {name=R239
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3260 3250 2 0 {name=R240
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 3070 2 0 {name=R241
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 3130 2 0 {name=R242
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 3190 2 0 {name=R243
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3600 3250 2 0 {name=R244
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 3070 2 0 {name=R245
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 3130 2 0 {name=R246
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 3190 2 0 {name=R247
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 3920 3250 2 0 {name=R248
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 3070 2 0 {name=R249
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 3130 2 0 {name=R250
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 3190 2 0 {name=R251
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4270 3250 2 0 {name=R252
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 3070 2 0 {name=R253
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 3130 2 0 {name=R254
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 3190 2 0 {name=R255
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {sky130_fd_pr/res_high_po_0p35.sym} 4600 3250 2 0 {name=R256
L=32.2
model=res_high_po_0p35
spiceprefix=X
mult=1}
C {devices/lab_pin.sym} -520 3280 3 0 {name=p33 sig_type=std_logic lab=v_res_top}
C {LNA/lna_tg.sym} 5350 1160 0 0 {name=x10}
C {devices/lab_pin.sym} 5430 1140 1 0 {name=p36 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 5390 1140 1 0 {name=p37 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 3620 2740 0 0 {name=x11}
C {devices/lab_pin.sym} 3700 2720 1 0 {name=p39 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 3660 2720 1 0 {name=p40 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 2310 2560 0 0 {name=x12}
C {devices/lab_pin.sym} 2390 2540 1 0 {name=p42 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 2350 2540 1 0 {name=p43 sig_type=std_logic lab=VSS_RES}
C {LNA/lna_tg.sym} 910 2370 0 0 {name=x13}
C {devices/lab_pin.sym} 990 2350 1 0 {name=p45 sig_type=std_logic lab=VDD_RES}
C {devices/lab_pin.sym} 950 2350 1 0 {name=p46 sig_type=std_logic lab=VSS_RES}
C {devices/lab_pin.sym} 890 2420 0 0 {name=p51 sig_type=std_logic lab=res_tune_decoder_out[0]}
C {devices/lab_pin.sym} 2290 2610 0 0 {name=p44 sig_type=std_logic lab=res_tune_decoder_out[1]}
C {devices/lab_pin.sym} 3600 2790 0 0 {name=p41 sig_type=std_logic lab=res_tune_decoder_out[2]}
C {devices/lab_pin.sym} 5330 1210 0 0 {name=p38 sig_type=std_logic lab=res_tune_decoder_out[3]}
C {devices/lab_pin.sym} 3550 1210 0 0 {name=p32 sig_type=std_logic lab=res_tune_decoder_out[4]}
C {devices/lab_pin.sym} 2280 1470 0 0 {name=p30 sig_type=std_logic lab=res_tune_decoder_out[5]}
C {devices/lab_pin.sym} 1010 1850 0 0 {name=p47 sig_type=std_logic lab=res_tune_decoder_out[6]}
C {devices/lab_pin.sym} -160 -1590 0 0 {name=p28 sig_type=std_logic lab=res_tune_decoder_out[7]}
C {devices/lab_pin.sym} 1070 -1360 0 0 {name=p18 sig_type=std_logic lab=res_tune_decoder_out[8]}
C {devices/lab_pin.sym} 2260 -1120 0 0 {name=p20 sig_type=std_logic lab=res_tune_decoder_out[9]}
C {devices/lab_pin.sym} 3540 -880 0 0 {name=p22 sig_type=std_logic lab=res_tune_decoder_out[10]}
C {devices/lab_pin.sym} 4800 -650 0 0 {name=p24 sig_type=std_logic lab=res_tune_decoder_out[11]}
