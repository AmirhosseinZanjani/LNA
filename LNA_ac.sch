v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N -746.25 -467.5 -746.25 -372.5 {
lab=InP_LNA}
N -871.25 -467.5 -871.25 -372.5 {
lab=InN_LNA}
N -1001.25 -467.5 -1001.25 -372.5 {
lab=VSS_LNA}
N -1126.25 -467.5 -1126.25 -372.5 {
lab=VDD_LNA}
N -746.25 -12.5 -746.25 82.5 {
lab=CM_LNA}
N -865 -16.25 -865 78.75 {
lab=OutP_LNA}
N -990 -16.25 -990 78.75 {
lab=OutN_LNA}
N -1140 -11.25 -1140 83.75 {
lab=Clock_CMFB_LNA}
N 20 -5 20 15 {
lab=VT2}
N 20 -5 280 -5 {
lab=VT2}
N 280 -5 280 15 {
lab=VT2}
N 20 75 20 135 {
lab=#net1}
N 280 75 280 135 {
lab=#net2}
N 60 375 240 375 {
lab=Vbias}
N 20 435 280 435 {
lab=VSS_LNA}
N 20 405 20 435 {
lab=VSS_LNA}
N 280 405 280 435 {
lab=VSS_LNA}
N 100 325 150 325 {
lab=Vbias}
N 150 -55 150 -5 {
lab=VT2}
N 150 -155 150 -115 {
lab=VT2}
N 190 -355 470 -355 {
lab=#net3}
N 150 -405 150 -385 {
lab=VDD_LNA}
N 150 -405 510 -405 {
lab=VDD_LNA}
N 510 -405 510 -385 {
lab=VDD_LNA}
N 130 -355 150 -355 {
lab=VDD_LNA}
N 130 -405 130 -355 {
lab=VDD_LNA}
N 130 -405 150 -405 {
lab=VDD_LNA}
N 510 -355 530 -355 {
lab=VDD_LNA}
N 530 -405 530 -355 {
lab=VDD_LNA}
N 510 -405 530 -405 {
lab=VDD_LNA}
N 20 45 50 45 {
lab=VT2}
N 260 45 280 45 {
lab=VT2}
N -10 375 20 375 {
lab=VSS_LNA}
N -10 375 -10 405 {
lab=VSS_LNA}
N 280 375 300 375 {
lab=VSS_LNA}
N 300 375 300 395 {
lab=VSS_LNA}
N 300 395 300 415 {
lab=VSS_LNA}
N -10 405 -10 415 {
lab=VSS_LNA}
N -120 45 -20 45 {
lab=InP_LNA}
N 320 45 410 45 {
lab=InN_LNA}
N 510 -55 510 125 {
lab=#net3}
N 510 295 510 345 {
lab=#net3}
N 280 435 510 435 {
lab=VSS_LNA}
N 510 405 510 435 {
lab=VSS_LNA}
N -10 415 -10 435 {
lab=VSS_LNA}
N -10 435 20 435 {
lab=VSS_LNA}
N 300 415 300 435 {
lab=VSS_LNA}
N 510 375 530 375 {
lab=VSS_LNA}
N 530 375 530 435 {
lab=VSS_LNA}
N 510 435 530 435 {
lab=VSS_LNA}
N 530 -405 1090 -405 {
lab=VDD_LNA}
N 1090 -405 1090 -395 {
lab=VDD_LNA}
N 890 -405 890 -395 {
lab=VDD_LNA}
N 880 -365 890 -365 {
lab=VDD_LNA}
N 860 -365 880 -365 {
lab=VDD_LNA}
N 860 -405 860 -365 {
lab=VDD_LNA}
N 1090 -365 1110 -365 {
lab=VDD_LNA}
N 1110 -405 1110 -365 {
lab=VDD_LNA}
N 1090 -405 1110 -405 {
lab=VDD_LNA}
N 930 55 1050 55 {
lab=CM_LNA}
N 1000 15 1000 55 {
lab=CM_LNA}
N 860 55 890 55 {
lab=VSS_LNA}
N 860 55 860 85 {
lab=VSS_LNA}
N 1090 55 1110 55 {
lab=VSS_LNA}
N 1110 55 1110 75 {
lab=VSS_LNA}
N 1090 85 1090 165 {
lab=#net2}
N 890 85 890 165 {
lab=#net1}
N 1090 165 1090 195 {
lab=#net2}
N 1110 -405 1650 -405 {
lab=VDD_LNA}
N 1450 -375 1470 -375 {
lab=VDD_LNA}
N 1470 -405 1470 -375 {
lab=VDD_LNA}
N 2460 -375 2490 -375 {
lab=VDD_LNA}
N 2460 -405 2460 -375 {
lab=VDD_LNA}
N 2490 -65 2490 35 {
lab=OutN_LNA}
N 2490 325 2490 365 {
lab=OutN_LNA}
N 1450 325 1450 365 {
lab=OutP_LNA}
N 2490 425 2490 435 {
lab=VSS_LNA}
N 1450 -75 1450 35 {
lab=OutP_LNA}
N 530 435 1430 435 {
lab=VSS_LNA}
N 1460 435 1680 435 {
lab=VSS_LNA}
N 1450 425 1450 435 {
lab=VSS_LNA}
N 1440 395 1450 395 {
lab=VSS_LNA}
N 1440 395 1440 435 {
lab=VSS_LNA}
N 2490 395 2500 395 {
lab=VSS_LNA}
N 2500 395 2500 435 {
lab=VSS_LNA}
N 2490 435 2500 435 {
lab=VSS_LNA}
N 1490 395 1500 395 {
lab=#net4}
N 2440 395 2450 395 {
lab=#net4}
N 1450 35 1450 155 {
lab=OutP_LNA}
N 2490 35 2490 155 {
lab=OutN_LNA}
N 510 125 510 235 {
lab=#net3}
N 1450 155 1450 265 {
lab=OutP_LNA}
N 2490 155 2490 265 {
lab=OutN_LNA}
N 280 215 280 245 {
lab=#net2}
N 20 215 20 245 {
lab=#net1}
N 930 -365 950 -365 {
lab=drain_m19}
N 1030 -365 1050 -365 {
lab=drain_m18}
N 1430 435 1460 435 {
lab=VSS_LNA}
N 2460 -405 2490 -405 {
lab=VDD_LNA}
N 890 -25 890 25 {
lab=drain_m19}
N 1090 -25 1090 25 {
lab=drain_m18}
N 890 -85 890 -25 {
lab=drain_m19}
N 1090 -85 1090 -25 {
lab=drain_m18}
N 890 -335 890 -305 {
lab=drain_m19}
N 1090 -335 1090 -305 {
lab=drain_m18}
N 280 135 280 215 {
lab=#net2}
N 20 135 20 215 {
lab=#net1}
N 150 -5 150 15 {
lab=VT2}
N 50 45 260 45 {
lab=VT2}
N 150 15 150 45 {
lab=VT2}
N 950 -365 950 -305 {
lab=drain_m19}
N 890 -305 950 -305 {
lab=drain_m19}
N 1030 -365 1030 -305 {
lab=drain_m18}
N 1030 -305 1090 -305 {
lab=drain_m18}
N 1650 -405 2400 -405 {
lab=VDD_LNA}
N 1680 435 2430 435 {
lab=VSS_LNA}
N 2430 435 2490 435 {
lab=VSS_LNA}
N 2400 -405 2460 -405 {
lab=VDD_LNA}
N -130 45 -120 45 {
lab=InP_LNA}
N 1450 -345 1450 -305 {
lab=OutP_LNA}
N 890 -135 890 -85 {
lab=drain_m19}
N 410 325 470 325 {
lab=Vbias}
N 150 325 410 325 {
lab=Vbias}
N 1090 -135 1090 -85 {
lab=drain_m18}
N 20 165 890 165 {
lab=#net1}
N 280 195 1090 195 {
lab=#net2}
N 150 -325 150 -155 {
lab=VT2}
N 890 -305 890 -135 {
lab=drain_m19}
N 1090 -305 1090 -135 {
lab=drain_m18}
N 1450 -305 1450 -135 {
lab=OutP_LNA}
N 2490 -345 2490 -165 {
lab=OutN_LNA}
N 2530 -375 2550 -375 {
lab=drain_m18}
N 1370 -375 1410 -375 {
lab=drain_m19}
N 150 325 150 375 {
lab=Vbias}
N 470 325 470 375 {
lab=Vbias}
N 510 235 510 295 {
lab=#net3}
N 1450 -135 1450 -75 {
lab=OutP_LNA}
N 2490 265 2490 325 {
lab=OutN_LNA}
N 1500 395 2440 395 {
lab=#net4}
N 1450 265 1450 325 {
lab=OutP_LNA}
N 2490 -175 2490 -65 {
lab=OutN_LNA}
N 890 -185 1370 -185 {
lab=drain_m19}
N 1370 -375 1370 -185 {
lab=drain_m19}
N 1090 -145 1490 -145 {
lab=drain_m18}
N 1490 -315 1490 -145 {
lab=drain_m18}
N 1490 -335 2550 -335 {
lab=drain_m18}
N 2550 -375 2550 -335 {
lab=drain_m18}
N 1490 -335 1490 -315 {
lab=drain_m18}
N 20 305 20 345 {
lab=#net1}
N 280 305 280 345 {
lab=#net2}
N 20 245 20 305 {
lab=#net1}
N 280 245 280 305 {
lab=#net2}
N -250 225 -250 255 {
lab=VDD_LNA}
N -250 315 -250 355 {
lab=Vbias}
N -280 385 -250 385 {
lab=VSS_LNA}
N -280 385 -280 435 {
lab=VSS_LNA}
N -280 435 -250 435 {
lab=VSS_LNA}
N -250 415 -250 435 {
lab=VSS_LNA}
N -210 385 -180 385 {
lab=Vbias}
N -180 335 -180 385 {
lab=Vbias}
N -250 335 -180 335 {
lab=Vbias}
N 150 -115 150 -55 {
lab=VT2}
N 510 -325 510 -55 {
lab=#net3}
N 450 -355 450 -295 {
lab=#net3}
N 450 -295 510 -295 {
lab=#net3}
N -250 435 -10 435 {
lab=VSS_LNA}
N 1748.75 36.25 1748.75 56.25 {
lab=#net5}
N 1668.75 -13.75 1708.75 -13.75 {
lab=OutN_LNA}
N 1668.75 -113.75 1708.75 -113.75 {
lab=OutP_LNA}
N 1978.75 16.25 1998.75 16.25 {
lab=#net4}
N 1708.75 -73.75 1708.75 -43.75 {
lab=f1}
N 1708.75 -43.75 1748.75 -43.75 {
lab=f1}
N 1748.75 -43.75 1748.75 -23.75 {
lab=f1}
N 1748.75 56.25 1858.75 56.25 {
lab=#net5}
N 1858.75 36.25 1858.75 56.25 {
lab=#net5}
N 1818.75 26.25 1818.75 56.25 {
lab=#net5}
N 1708.75 26.25 1708.75 56.25 {
lab=#net5}
N 1708.75 56.25 1748.75 56.25 {
lab=#net5}
N 1818.75 -123.75 1818.75 -13.75 {
lab=f2}
N 1748.75 -143.75 1818.75 -143.75 {
lab=f2}
N 1818.75 -143.75 1818.75 -123.75 {
lab=f2}
N 1858.75 -43.75 1858.75 -23.75 {
lab=f3}
N 1858.75 -43.75 1908.75 -43.75 {
lab=f3}
N 1908.75 16.25 1918.75 16.25 {
lab=#net5}
N 1908.75 -43.75 1928.75 -43.75 {
lab=f3}
N 1908.75 16.25 1908.75 56.25 {
lab=#net5}
N 1858.75 56.25 1908.75 56.25 {
lab=#net5}
N 1748.75 -63.75 1798.75 -63.75 {
lab=#net5}
N 1798.75 -63.75 1798.75 56.25 {
lab=#net5}
N 1808.75 56.25 1808.75 76.25 {
lab=#net5}
N 1968.75 -43.75 2078.75 -43.75 {
lab=CM_LNA}
N 1668.75 116.25 1948.75 116.25 {
lab=CM_LNA}
N 1948.75 116.25 2078.75 116.25 {
lab=CM_LNA}
N 2078.75 -43.75 2078.75 116.25 {
lab=CM_LNA}
N 1808.75 76.25 1808.75 166.25 {
lab=#net5}
N 1668.75 166.25 1808.75 166.25 {
lab=#net5}
N 1748.75 -143.75 1748.75 -123.75 {
lab=f2}
N 1928.75 -33.75 1928.75 -23.75 {
lab=f3}
N 1968.75 -43.75 1968.75 -33.75 {
lab=CM_LNA}
N 1928.75 -43.75 1928.75 -33.75 {
lab=f3}
N 1968.75 -33.75 1968.75 -23.75 {
lab=CM_LNA}
N 1450 -113.75 1668.75 -113.75 {
lab=OutP_LNA}
N 1998.75 16.25 2000 393.75 {
lab=#net4}
N 2000 393.75 2000 395 {
lab=#net4}
C {devices/iopin.sym} -746.25 -467.5 3 0 {name=p8 lab=InP_LNA}
C {devices/iopin.sym} -871.25 -467.5 3 0 {name=p9 lab=InN_LNA}
C {devices/iopin.sym} -1001.25 -467.5 3 0 {name=p10 lab=VSS_LNA}
C {devices/iopin.sym} -1126.25 -467.5 3 0 {name=p11 lab=VDD_LNA}
C {devices/lab_pin.sym} -746.25 -372.5 3 0 {name=p12 sig_type=std_logic lab=InP_LNA}
C {devices/lab_pin.sym} -871.25 -372.5 3 0 {name=p13 sig_type=std_logic lab=InN_LNA}
C {devices/lab_pin.sym} -1001.25 -372.5 3 0 {name=p14 sig_type=std_logic lab=VSS_LNA}
C {devices/lab_pin.sym} -1126.25 -372.5 3 0 {name=p15 sig_type=std_logic lab=VDD_LNA}
C {devices/iopin.sym} -746.25 -12.5 3 0 {name=p33 lab=CM_LNA}
C {devices/lab_pin.sym} -746.25 82.5 3 0 {name=p26 sig_type=std_logic lab=CM_LNA}
C {devices/opin.sym} -865 -16.25 3 0 {name=p28 lab=OutP_LNA}
C {devices/opin.sym} -990 -16.25 3 0 {name=p47 lab=OutN_LNA}
C {devices/lab_pin.sym} -865 78.75 1 1 {name=p49 sig_type=std_logic lab=OutP_LNA}
C {devices/lab_pin.sym} -990 78.75 1 1 {name=p50 sig_type=std_logic lab=OutN_LNA}
C {devices/iopin.sym} -1140 -11.25 3 0 {name=p53 lab=Clock_CMFB_LNA}
C {devices/lab_pin.sym} -1140 83.75 3 0 {name=p54 sig_type=std_logic lab=Clock_CMFB_LNA}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 0 45 0 0 {name=M4
L=10
W=90
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 300 45 0 1 {name=M5
L=10
W=90
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 40 375 0 1 {name=M8
L=20
W=10
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 260 375 0 0 {name=M9
L=20
W=10
nf=1 
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1070 -365 0 0 {name=M16
L=20
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 910 -365 0 1 {name=M17
L=20
W=6
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1070 55 0 0 {name=M18
L=20
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 910 55 0 1 {name=M19
L=20
W=1
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1430 -375 0 0 {name=M20
L=20
W=6
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 2510 -375 0 1 {name=M21
L=20
W=6
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2470 395 0 0 {name=M23
L=20
W=6
nf=1 
mult=7
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1470 395 0 1 {name=M25
L=20
W=6
nf=1 
mult=7
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 1090 -5 0 1 {name=p17 sig_type=std_logic lab=drain_m18}
C {devices/lab_pin.sym} 890 -5 0 0 {name=p18 sig_type=std_logic lab=drain_m19}
C {devices/lab_pin.sym} 280 -5 0 1 {name=p21 sig_type=std_logic lab=VT2}
C {devices/ngspice_get_value.sym} 30 -345 0 0 {name=r46 node=v(@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/lab_pin.sym} 100 325 0 0 {name=p19 sig_type=std_logic lab=Vbias}
C {devices/ngspice_get_value.sym} 30 -375 0 0 {name=r24 node=v(@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_value.sym} 580 -375 0 0 {name=r25 node=v(@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_value.sym} 580 -345 0 0 {name=r26 node=v(@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_expr.sym} 30 -315 0 0 {name=r27 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_expr.sym} 580 -315 0 0 {name=r28 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 30 -285 0 0 {name=r29 node=v(@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_value.sym} 580 -285 0 0 {name=r30 node=v(@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 30 -255 0 0 {name=r31 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm1.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_expr.sym} 580 -255 0 0 {name=r32 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm2.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} -270 25 0 0 {name=r19 node=v(@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} -270 -5 0 0 {name=r20 node=v(@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} -270 55 0 0 {name=r23 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} -270 85 0 0 {name=r43 node=v(@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} -270 115 0 0 {name=r44 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm4.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm10.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} 350 15 0 0 {name=r47 node=v(@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 350 -15 0 0 {name=r48 node=v(@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 350 45 0 0 {name=r49 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 350 75 0 0 {name=r50 node=v(@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 350 105 0 0 {name=r51 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm5.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} 760 -345 0 0 {name=r52 node=v(@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 760 -375 0 0 {name=r53 node=v(@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 760 -315 0 0 {name=r54 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 760 -285 0 0 {name=r55 node=v(@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 760 -255 0 0 {name=r56 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} 1310 -345 0 0 {name=r62 node=v(@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 1310 -375 0 0 {name=r63 node=v(@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 1310 -315 0 0 {name=r64 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 1310 -285 0 0 {name=r65 node=v(@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 1310 -255 0 0 {name=r66 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm20.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} 2570 -355 0 0 {name=r67 node=v(@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 2570 -385 0 0 {name=r68 node=v(@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 2570 -325 0 0 {name=r69 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 2570 -295 0 0 {name=r70 node=v(@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 2570 -265 0 0 {name=r71 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm21.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} -320 375 0 1 {name=r72 node=v(@m.xm8.msky130_fd_pr__nfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} -320 345 0 1 {name=r73 node=v(@m.xm8.msky130_fd_pr__nfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} -320 405 0 1 {name=r74 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm8.msky130_fd_pr__nfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm8.msky130_fd_pr__nfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} -320 435 0 1 {name=r75 node=v(@m.xm8.msky130_fd_pr__nfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_value.sym} 340 385 0 0 {name=r77 node=v(@m.xm9.msky130_fd_pr__nfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 340 355 0 0 {name=r78 node=v(@m.xm9.msky130_fd_pr__nfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 340 415 0 0 {name=r79 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm9.msky130_fd_pr__nfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm9.msky130_fd_pr__nfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 340 445 0 0 {name=r80 node=v(@m.xm9.msky130_fd_pr__nfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_value.sym} 1180 45 0 0 {name=r82 node=v(@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 1180 15 0 0 {name=r83 node=v(@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 1180 75 0 0 {name=r84 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 1180 105 0 0 {name=r85 node=v(@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 1180 135 0 0 {name=r86 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm18.msky130_fd_pr__nfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/ngspice_get_value.sym} 750 45 0 0 {name=r87 node=v(@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 750 15 0 0 {name=r88 node=v(@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 750 75 0 0 {name=r89 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 750 105 0 0 {name=r90 node=v(@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 750 135 0 0 {name=r91 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm19.msky130_fd_pr__nfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 170 -355 0 1 {name=M1
L=20
W=2
nf=1
mult=6
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 490 -355 0 0 {name=M2
L=20
W=2
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/ngspice_get_value.sym} 1180 -345 0 0 {name=r22 node=v(@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth"}
C {devices/ngspice_get_value.sym} 1180 -375 0 0 {name=r57 node=v(@m.xm16.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs"}
C {devices/ngspice_get_expr.sym} 1180 -315 0 0 {name=r58 node="[format %.2g [expr [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] - [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vod"}
C {devices/ngspice_get_value.sym} 1180 -285 0 0 {name=r59 node=v(@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vds])
descr="vds"}
C {devices/ngspice_get_expr.sym} 1180 -255 0 0 {name=r60 node="[format %.3g [expr [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vds]\\\}] - [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vgs]\\\}] + [ngspice::get_voltage \\\{@m.xm17.msky130_fd_pr__pfet_01v8_lvt[vth]\\\}]]]"
descr="vds-vod"}
C {devices/isource.sym} -250 285 0 1 {name=I0 value=50n}
C {sky130_fd_pr/nfet_01v8_lvt.sym} -230 385 0 1 {name=M3
L=20
W=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} -180 335 0 1 {name=p48 sig_type=std_logic lab=Vbias}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 490 375 0 0 {name=M6
L=20
W=10
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_pin.sym} 408.75 45 2 0 {name=p29 sig_type=std_logic lab=InN_LNA}
C {devices/lab_pin.sym} 983.75 435 3 0 {name=p30 sig_type=std_logic lab=VSS_LNA}
C {devices/lab_pin.sym} 860 85 3 0 {name=p2 sig_type=std_logic lab=VSS_LNA}
C {devices/lab_pin.sym} 1110 75 3 0 {name=p20 sig_type=std_logic lab=VSS_LNA}
C {devices/lab_pin.sym} -250 225 0 0 {name=p22 sig_type=std_logic lab=VDD_LNA}
C {devices/lab_pin.sym} 403.75 -405 1 0 {name=p23 sig_type=std_logic lab=VDD_LNA}
C {devices/lab_pin.sym} 1000 15 0 0 {name=p1 sig_type=std_logic lab=CM_LNA}
C {devices/lab_pin.sym} 2490 -36.25 0 1 {name=p4 sig_type=std_logic lab=OutN_LNA}
C {devices/lab_pin.sym} 1450 30 2 1 {name=p5 sig_type=std_logic lab=OutP_LNA}
C {devices/lab_pin.sym} -130 45 0 0 {name=p6 sig_type=std_logic lab=InP_LNA}
C {LNA/Clock_generator.sym} -270 -400 0 0 {name=X7}
C {devices/lab_pin.sym} -400 -400 0 0 {name=p7 sig_type=std_logic lab=Clock_CMFB_LNA}
C {devices/lab_pin.sym} -270 -470 1 0 {name=p16 sig_type=std_logic lab=VDD_LNA}
C {devices/lab_pin.sym} -270 -320 3 0 {name=p24 sig_type=std_logic lab=VSS_LNA}
C {devices/lab_pin.sym} -140 -420 2 0 {name=p25 sig_type=std_logic lab=Q1}
C {devices/lab_pin.sym} -140 -380 2 0 {name=p27 sig_type=std_logic lab=Q2}
C {devices/vcvs.sym} 1748.75 6.25 0 0 {name=E3 value=-1
}
C {devices/vcvs.sym} 1748.75 -93.75 0 0 {name=E4 value=1}
C {devices/vcvs.sym} 1858.75 6.25 0 0 {name=E5 value=0.5}
C {devices/vcvs.sym} 1948.75 16.25 1 0 {name=E6 value=\{-500\}

}
C {devices/lab_pin.sym} 1818.75 -113.75 2 1 {name=p34 sig_type=std_logic lab=f2}
C {devices/lab_pin.sym} 1708.75 -53.75 2 1 {name=p35 sig_type=std_logic lab=f1}
C {devices/lab_pin.sym} 1888.75 -43.75 2 1 {name=p36 sig_type=std_logic lab=f3}
C {devices/lab_pin.sym} 1670 -13.75 2 1 {name=p37 sig_type=std_logic lab=OutN_LNA}
C {devices/lab_pin.sym} 1668.75 116.25 0 0 {name=p31 sig_type=std_logic lab=CM_LNA}
C {devices/lab_pin.sym} 1668.75 166.25 3 0 {name=p3 sig_type=std_logic lab=VSS_LNA}
